# Altium project 02_01 LilyPad.PrjPcb
2 sheets, 0 parts. Net scope: global (net labels, ports and power ports of the same name join across sheets).
Sheets:
  LilyPad_1.SchDoc
  LilyPad_2.SchDoc

## Sheet LilyPad_1.SchDoc
size A4

## Sheet LilyPad_2.SchDoc
size A4